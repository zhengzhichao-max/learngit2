# Keil uVision project Project.uvprojx, settings and files
target XH7_EC20_ZTC_V300 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ..\tr9_hex_bin\V1d0d13T +hex
  AfterMake: fromelf --bin ".\TR9_V400\@L.axf" --output ".\tr_bin_lib\@L.bin"
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,USE_STM3210C_EVAL,USE_USB_OTG_FS,nullFun=//
  c misc: --C99 --diag_suppress=161
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\source\STM32_Usb;..\..\..\..\source\STM32_Usb\include;..\..\..\..\source\fatfs;..\..\..\..\source\fatfs\fatfs;..\..\..\..\source\sysTick;..\..\..\..\source\include;..\..\..\..\source\dev;..\..\..\..\source\dev\lsm6ds3trc;..\..\..\..\source\dev\rx8025t;..\..\..\..\source\drv;..\..\..\..\source\mid;..\..\..\..\source\mid\monitor;..\..\..\..\source\mid\slave_mcu\slv_include;..\..\..\..\source\mid\slave_mcu\print_driver;..\..\..\..\source\mid\slave_mcu\tf_card;..\..\..\..\source\mid\slave_mcu\i2c_eeprom;..\..\..\..\source\mid\slave_mcu\ic4442_card;..\..\..\..\source\mid\slave_mcu\lcd_driver;..\..\..\..\source\mid\slave_mcu\tf_card;..\..\..\..\source\mid\slave_mcu\menu_process;..\..\..\..\source\task\lsm6ds3trc;..\..\..\..\source\test;..\..\..\..\source\app\self_chk;..\..\..\..\source\app\tr9
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7f400
  memory RVCT9: RAM 0x20000000 size 0x16000
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_exti.c stm32f10x_can.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_dma.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group systick
    ../../../../source/sysTick/: systick.c
  group define
    ../../../../source/include/: define.h
  group mian
    ../../../../source/mid/main/: main.c
  group app
    ../../../../source/app/debug/: debug.c
    ../../../../source/app/app_cfg/: app_cfg.c
    ../../../../source/app/net/: jt808_type.c jt808_recive.c jt808_manage.c jt808_package.c jt808_parse.c
    ../../../../source/app/rcd_2012/: rcd_manage.c rcd_communicate.c
    ../../../../source/app/report/: report.c
    ../../../../source/app/upgrade/: upgrade.c
    ../../../../source/app/sms/: gbt_19056_2012_biao_c_1_ic_card.c sms_parse.c
    ../../../../source/app/print/: print_2012.c print_2003.c
    ../../../../source/app/can/: can.c
    ../../../../source/app/tr9/: tr9_frame.c tr9_agree.c
    ../../../../source/app/self_chk/: self_chk.c
  group device
    ../../../../source/dev/: dev_test.c
    ../../../../source/dev/lsm6ds3trc/: lsm6ds3trc_adj.c lsm6ds3trc.c
    ../../../../source/dev/rx8025t/: rx8025t.c
  group drv
    ../../../../source/drv/: drv_test.c
    ../../../../source/drv/gps_drv/: gps_drv.c
    ../../../../source/drv/gsm_drv/: gsm_drv.c
    ../../../../source/drv/mcu_it/: stm32f10x_it.c
    ../../../../source/drv/uart1/: uart1.c
    ../../../../source/drv/spi_flash/: spi_flash.c
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_i2c.c
    ../../../../source/drv/uart2/: uart2.c
    ../../../../source/drv/adc/: adc.c
    ../../../../source/drv/i2c/: I2C.c
    ../../../../source/drv/uart3/: uart3.c
    ../../../../source/drv/drv_cfg/: drv_cfg_tr9.c
  group mid
    ../../../../source/mid/: mid_test.c
    ../../../../source/mid/logger/: logger.c
    ../../../../source/mid/gps_manage/: gps_manage.c
    ../../../../source/mid/handset/: handset.c
    ../../../../source/mid/pub/: clib.c pub.c
    ../../../../source/mid/send/: send.c
    ../../../../source/mid/tts/: tts.c
    ../../../../source/mid/uart/: uart_pub.c
    ../../../../source/mid/mid_cfg/: mid_cfg.c
    ../../../../source/mid/slave_mcu/call_record/: call_record.c
    ../../../../source/mid/slave_mcu/card_scan/: card_scan.c
    ../../../../source/mid/slave_mcu/data_inter_action/: data_interaction.c
    ../../../../source/mid/slave_mcu/hard_config/: hard_config.c
    ../../../../source/mid/slave_mcu/lcd_driver/: key_state.c lcd13264_ram.c
    ../../../../source/mid/slave_mcu/menu_process/: menu_process.c
    ../../../../source/mid/slave_mcu/phone_book/: phone_book.c
    ../../../../source/mid/slave_mcu/recorder/: recorder.c
    ../../../../source/mid/slave_mcu/sms_process/: sms_process.c
    ../../../../source/mid/slave_mcu/print_driver/: print_driver.c
    ../../../../source/mid/slave_mcu/i2c_eeprom/: at24cxx_driver.c iic_base_driver.c
    ../../../../source/mid/slave_mcu/tf_card/: cc936.c ccsbcs.c
    ../../../../source/mid/gsm_manage/: gsm_ec20.c
    ../../../../source/mid/slave_mcu/ic4442_card/: ic4442_driver.c
  group mid/monitor
    ../../../../source/mid/monitor/: monitor.c monitor_table.c monitor_mcu_flash.c monitor_util.c
  group task
    ../../../../source/task/lsm6ds3trc/: lsm6ds3trc_task.c
  group test
    ../../../../source/test/: test.c
  group readme
    ../../../../: Readme.txt
